FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0004-osd32mp1-brk-initial-support.patch \ 
            "